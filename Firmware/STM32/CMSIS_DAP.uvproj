# Keil uVision project CMSIS_DAP.uvproj, settings and files
target CMSIS-DAP (ARM-ADS)
  device: STM32F102C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS-DAP
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c include: .;.\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: .\CMSIS_DAP.sct
  group CMSIS-DAP
    ./: startup_stm32f10x_hd.s startup_stm32f10x_md.s system_stm32f10x.c CMSIS-DAP.c UserApp.c usb_config.c usbd_STM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c CMSIS_DAP.sct
  group Lib
    ./: USB_CM3.lib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_flash.c
